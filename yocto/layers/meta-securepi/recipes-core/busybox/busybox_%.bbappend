FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://suid-disable.cfg"
